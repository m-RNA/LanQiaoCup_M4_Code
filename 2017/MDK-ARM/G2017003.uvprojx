# Keil uVision project G2017003.uvprojx, settings and files
target G2017003 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G2017003 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;  ..\Bsp\Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c gpio.c rtc.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Bsp
    ../Bsp/: bsp.c lcd.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
